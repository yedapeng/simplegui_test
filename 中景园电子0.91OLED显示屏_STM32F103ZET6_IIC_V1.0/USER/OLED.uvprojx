# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\CORE;..\..\DemoProc\inc;..\..\HMI\inc;..\..\GUI\inc;..\..\Transplant\STM32F1\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../../DemoProc/src/: DemoProc.c List.c RealtimeGraph.c RTCNotice.c ScrollingText.c TextNotice.c VariableBox.c
    ../../Transplant/STM32F1/src/: GPIO.c main.c OLED.c Redirect.c RTC.c SSD1306_SPI.c Timer.c Usart.c
  group GUI
    ../../GUI/src/: SGUI_Basic.c SGUI_Common.c SGUI_FlashData.c SGUI_Frame.c SGUI_Interface.c SGUI_List.c SGUI_Notice.c SGUI_ProcessBar.c SGUI_RealtimeGraph.c SGUI_ScrollBar.c SGUI_Text.c SGUI_VariableBox.c
  group HMI
    ../../HMI/src/: HMI_Engine.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
    ./: system_stm32f10x.c stm32f10x_it.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.2.0
